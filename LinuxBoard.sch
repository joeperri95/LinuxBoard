File: LinuxBoard.sch (KiCad schematic (older format))
At the start: 17 parts

Commit message: Schematic signoff
Other:
- note added: "Add more as needed\n"
